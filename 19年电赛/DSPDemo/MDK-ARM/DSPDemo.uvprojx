# Keil uVision project DSPDemo.uvprojx, settings and files
target DSPDemo (6220000::V6.22::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: DSPDemo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,DATA_IN_ExtSDRAM
  c include: ../clock;../BSP;../moder;../DSPLIB/Source;../DSPLIB/PrivateInclude;../DSPLIB/Include;../DSPLIB/ComputeLibrary;../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: DSPDemo\DSPDemo.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fmc.c i2c.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group DSP
    ../DSPLIB/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../DSPLIB/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ../DSPLIB/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ../DSPLIB/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../DSPLIB/Source/ControllerFunctions/: ControllerFunctions.c
    ../DSPLIB/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ../DSPLIB/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ../DSPLIB/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ../DSPLIB/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ../DSPLIB/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../DSPLIB/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../DSPLIB/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ../DSPLIB/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ../DSPLIB/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ../DSPLIB/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
    ../DSPLIB/Source/WindowFunctions/: WindowFunctions.c
  group moder
    ../moder/: led.c Midfilter.c Upper.c LMS_norm.c spline.c thd.c SI5351.c Si5351A-RevB-Registers.h headers.h AD9854_Parallel.c AD9854_Parallel.h
    ../clock/: Si5351A2.h Si5351A3.h
  group BSP
    ../BSP/: BSP_ADC.C
  group FFT
    ../moder/: fft.c FFTInc.h ifft.c Digital_Filter.c
software components: CMSIS:CORE 6.1.1
